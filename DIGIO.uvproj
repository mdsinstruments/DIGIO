# Keil uVision project DIGIO.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: DIGIO +hex
  AfterMake: C:\Cypress\USB\bin\Hex2bix.exe -i -f 0xC2 -p 0x0130 -o .\obj\DIGIO.iic .\obj\DIGIO.hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./source/: DIGIO.c DSCR.A51 EZUSB.LIB fw.c fx2sdly.h
